* Title: Test circuit

* Netlist
LA1 n29 n24 20.0 ic=1.0E-6
LB1 n35 n28 10.0 ic=0.0
K1 LA1 LB1 1.0
R3 n38 n29 50.0
R10 n28 0 0
R11 n24 0 0
V17 n38 n24 100.0
R18 n35 n28 20.0

.control
op
tran 0.01 5.0 0 uic
echo output test > result.txt $ start new file
set appendwrite
set wr_vecnames
set wr_singlescale
wrdata data.txt all
.endc
