* Title: Test circuit

* Netlist
R3 n18 n17 50.0
V4 n18 n14 100.0
R8 n17 n14 50.0
R11 n14 0 0

.control
op
tran 0.1 5.0 0
echo output test > result.txt $ start new file
set appendwrite
set wr_vecnames
set wr_singlescale
wrdata data.txt all
.endc
