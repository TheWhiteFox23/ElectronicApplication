* Title: Test circuit

* Netlist
R0 n31 n30 50.0
R3 n30 n21 50.0
R9 n21 0 0
L10 n30 n21 200.0 ic=10.0
V14 n31 n21 100.0

.control
op
tran 0.1 5.0 0 uic
echo output test > result.txt $ start new file
set appendwrite
set wr_vecnames
set wr_singlescale
wrdata data.txt all
.endc
